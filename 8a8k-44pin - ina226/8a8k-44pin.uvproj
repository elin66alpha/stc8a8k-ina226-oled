# Keil uVision project 8a8k-44pin.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: 8a8k-44pin +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: C:\Keil_v5\C51
  group Source Group 1
    ./: STARTUP.A51 main.c
  group New Group
    ./: pwm.c oled.c uart3.h uart2.h timer.c ina226.c IIC.c
